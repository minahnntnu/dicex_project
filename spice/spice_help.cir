*INDEPENDENT CURRENT SOURSCES

*I<name> <from> <to> dc <number> ac <number>
I1 0 VDN dc In
I2 VDN 0 dc Ip

*INDEPENDENT COLTAGE SOURCE

*V<name> <+> <-> dc <number> ac <number>
V1 VSS 0 dc 0
V2 VDD 0 dc 1.5

*RESISTOR

*R<name> <node 1> <node 2> <value>
R1 N1 N2 10k

*CAPACITORS
*C<name> <node 1> <node 2> <value>
C1 N1 N2 1u

*TRANSISTORS
*BSIM 4.5 has been downloaded from http://bsim.berkeley.edu/models/bsim4/
*M<name> <drain> <gate> <source> <bulk> <modelname> [parameters]
.include ../../models/ptm_130.spi
M1 VDN VDN VSS VSS nmos W=0.6u L=0.15u
